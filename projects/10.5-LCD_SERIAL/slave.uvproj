# Keil uVision project slave.uvproj, settings and files
target courseworks (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib
  group LIB
    ../../lib/: base.c base.h STARTUP.A51 hex_display.c hex_display.h
  group USER
    ./: slave.c
