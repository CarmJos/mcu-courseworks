# Keil uVision project master.uvproj, settings and files
target courseworks (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: master +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib
  group LIB
    ../../lib/: base.c base.h STARTUP.A51 matrix4_keyspad.c matrix4_keyspad.h
  group USER
    ./: master.c lcd1602.c lcd1602.h
