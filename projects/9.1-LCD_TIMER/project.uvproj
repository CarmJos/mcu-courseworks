# Keil uVision project project.uvproj, settings and files
target courseworks (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib
  group LIB
    ../../lib/: base.c base.h STARTUP.A51 button.c button.h
  group USER
    ./: main.c lcd1602.c lcd1602.h
